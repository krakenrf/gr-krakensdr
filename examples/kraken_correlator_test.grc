options:
  parameters:
    description: You must modify the code to have the noise source forced ON in the heimdall code to run this test. Consult krakensdr_docs Wiki for instructions.
    generate_options: qt_gui
    id: kraken_corr_test
    output_language: python
    title: KrakenSDR Correlator Test
  states: {}

blocks:
- name: fft_cut
  id: variable
  parameters:
    value: '4096'
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    type: real
    value: '416.588'
  states: {}
- name: vec_len
  id: variable
  parameters:
    value: 2**20
  states: {}
- name: blocks_stream_to_vector_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_0
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_1
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_2
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: blocks_stream_to_vector_0_0_0_0_3
  id: blocks_stream_to_vector
  parameters:
    num_items: vec_len
    type: complex
  states: {}
- name: krakensdr_krakensdr_correlator_0
  id: krakensdr_krakensdr_correlator
  parameters:
    fft_cut: fft_cut
    vec_len: vec_len
  states: {}
- name: krakensdr_krakensdr_correlator_0_0
  id: krakensdr_krakensdr_correlator
  parameters:
    fft_cut: fft_cut
    vec_len: vec_len
  states: {}
- name: krakensdr_krakensdr_correlator_0_0_0
  id: krakensdr_krakensdr_correlator
  parameters:
    fft_cut: fft_cut
    vec_len: vec_len
  states: {}
- name: krakensdr_krakensdr_correlator_0_0_1
  id: krakensdr_krakensdr_correlator
  parameters:
    fft_cut: fft_cut
    vec_len: vec_len
  states: {}
- name: krakensdr_krakensdr_source_0
  id: krakensdr_krakensdr_source
  parameters:
    cpi_size: '1048576'
    ctrlPort: '5001'
    debug: 'False'
    freq: freq
    gain: '[30, 30, 30, 30, 30]'
    ipAddr: 127.0.0.1
    numChannels: '5'
    port: '5000'
  states: {}
- name: note_0
  id: note
  parameters:
    note: The heimdall code must be modified to keep the noise source always ON. See Wiki docs for info.
  states: {}
- name: phase_01
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: phase_02
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: phase_03
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: phase_04
  id: qtgui_number_sink
  parameters:
    graph_type: qtgui.NUM_GRAPH_HORIZ
    type: float
  states: {}
- name: qtgui_vector_sink_f_0
  id: qtgui_vector_sink_f
  parameters:
    name: XCorr_01
    vlen: fft_cut
    x_start: '0'
    x_step: '1.0'
    ymax: '0'
    ymin: '-50'
  states: {}
- name: qtgui_vector_sink_f_0_0
  id: qtgui_vector_sink_f
  parameters:
    name: X_Corr_02
    vlen: fft_cut
    x_start: '0'
    x_step: '1.0'
    ymax: '0'
    ymin: '-50'
  states: {}
- name: qtgui_vector_sink_f_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    name: X_Corr_03
    vlen: fft_cut
    x_start: '0'
    x_step: '1.0'
    ymax: '0'
    ymin: '-50'
  states: {}
- name: qtgui_vector_sink_f_0_0_0_0
  id: qtgui_vector_sink_f
  parameters:
    name: X_Corr_04
    vlen: fft_cut
    x_start: '0'
    x_step: '1.0'
    ymax: '0'
    ymin: '-50'
  states: {}

connections:
- [blocks_stream_to_vector_0_0_0_0, '0', krakensdr_krakensdr_correlator_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', krakensdr_krakensdr_correlator_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', krakensdr_krakensdr_correlator_0_0_0, '0']
- [blocks_stream_to_vector_0_0_0_0, '0', krakensdr_krakensdr_correlator_0_0_1, '0']
- [blocks_stream_to_vector_0_0_0_0_0, '0', krakensdr_krakensdr_correlator_0, '1']
- [blocks_stream_to_vector_0_0_0_0_1, '0', krakensdr_krakensdr_correlator_0_0, '1']
- [blocks_stream_to_vector_0_0_0_0_2, '0', krakensdr_krakensdr_correlator_0_0_0, '1']
- [blocks_stream_to_vector_0_0_0_0_3, '0', krakensdr_krakensdr_correlator_0_0_1, '1']
- [krakensdr_krakensdr_correlator_0, '0', qtgui_vector_sink_f_0, '0']
- [krakensdr_krakensdr_correlator_0, '1', phase_01, '0']
- [krakensdr_krakensdr_correlator_0_0, '0', qtgui_vector_sink_f_0_0, '0']
- [krakensdr_krakensdr_correlator_0_0, '1', phase_02, '0']
- [krakensdr_krakensdr_correlator_0_0_0, '0', qtgui_vector_sink_f_0_0_0, '0']
- [krakensdr_krakensdr_correlator_0_0_0, '1', phase_03, '0']
- [krakensdr_krakensdr_correlator_0_0_1, '0', qtgui_vector_sink_f_0_0_0_0, '0']
- [krakensdr_krakensdr_correlator_0_0_1, '1', phase_04, '0']
- [krakensdr_krakensdr_source_0, '0', blocks_stream_to_vector_0_0_0_0, '0']
- [krakensdr_krakensdr_source_0, '1', blocks_stream_to_vector_0_0_0_0_0, '0']
- [krakensdr_krakensdr_source_0, '2', blocks_stream_to_vector_0_0_0_0_1, '0']
- [krakensdr_krakensdr_source_0, '3', blocks_stream_to_vector_0_0_0_0_2, '0']
- [krakensdr_krakensdr_source_0, '4', blocks_stream_to_vector_0_0_0_0_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
