options:
  parameters:
    generate_options: qt_gui
    id: kraken_fft_display
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: cpi_size
  id: variable
  parameters:
    value: 2**20
  states: {}
- name: freq
  id: variable_qtgui_entry
  parameters:
    gui_hint: (0,0)
    label: Center Frequency [MHz]
    type: real
    value: '416.588'
  states: {}
- name: gain
  id: variable_qtgui_entry
  parameters:
    gui_hint: (0,1)
    label: Gain [0 - 49.6]
    type: real
    value: '40.2'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '2400000'
  states: {}
- name: blocks_vector_to_stream_0
  id: blocks_vector_to_stream
  parameters:
    num_items: cpi_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_0
  id: blocks_vector_to_stream
  parameters:
    num_items: cpi_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_1
  id: blocks_vector_to_stream
  parameters:
    num_items: cpi_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_2
  id: blocks_vector_to_stream
  parameters:
    num_items: cpi_size
    type: complex
  states: {}
- name: blocks_vector_to_stream_0_3
  id: blocks_vector_to_stream
  parameters:
    num_items: cpi_size
    type: complex
  states: {}
- name: krakensdr_krakensdr_source_0
  id: krakensdr_krakensdr_source
  parameters:
    cpi_size: '1048576'
    ctrlPort: '5001'
    debug: 'False'
    freq: freq
    gain: '[gain, gain, gain, gain, gain]'
    ipAddr: 127.0.0.1
    numChannels: '5'
    port: '5000'
  states: {}
- name: qtgui_sink_x_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '16384'
    gui_hint: (1,0)
    name: ch_0
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '16384'
    gui_hint: (1,1)
    name: ch_1
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '16384'
    gui_hint: (2,0)
    name: ch_2
    plotconst: 'False'
    plottime: 'False'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '16384'
    gui_hint: (2,1)
    name: ch_3
    showrf: 'True'
    type: complex
  states: {}
- name: qtgui_sink_x_0_0_0_0_0
  id: qtgui_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '16384'
    gui_hint: (3,0)
    name: ch_4
    plotconst: 'False'
    plottime: 'False'
    showrf: 'True'
    type: complex
  states: {}

connections:
- [blocks_vector_to_stream_0, '0', qtgui_sink_x_0, '0']
- [blocks_vector_to_stream_0_0, '0', qtgui_sink_x_0_0, '0']
- [blocks_vector_to_stream_0_1, '0', qtgui_sink_x_0_0_0, '0']
- [blocks_vector_to_stream_0_2, '0', qtgui_sink_x_0_0_0_0, '0']
- [blocks_vector_to_stream_0_3, '0', qtgui_sink_x_0_0_0_0_0, '0']
- [krakensdr_krakensdr_source_0, '0', blocks_vector_to_stream_0, '0']
- [krakensdr_krakensdr_source_0, '1', blocks_vector_to_stream_0_0, '0']
- [krakensdr_krakensdr_source_0, '2', blocks_vector_to_stream_0_1, '0']
- [krakensdr_krakensdr_source_0, '3', blocks_vector_to_stream_0_2, '0']
- [krakensdr_krakensdr_source_0, '4', blocks_vector_to_stream_0_3, '0']

metadata:
  file_format: 1
  grc_version: 3.10.3.0
